# Keil uVision project robot_kontrol.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot_kontrol
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User Application
    ./: main.c RCC_SystemClock_Config.c RCC_SystemClock_Config.h Delay.c Delay.h SPI.c SPI.h I2C.c I2C.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
